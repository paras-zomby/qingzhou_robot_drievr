# Keil uVision project std_project.uvprojx, settings and files
target STM32F103RCT6 (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32F103RC STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.3.0
  cpu: IRAM(0x20000000,0x0000C000) IROM(0x08000000,0x00040000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: STM32F103RCT6 +hex
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=3 v6LangP=3 wLevel=2
  c define: STM32F10X_HD,USE_STDPERIPH_DRIVER
  c misc: --cpp11
  c include: ..\Libraries\CMSIS;..\Libraries\STM32F10x_StdPeriph_Driver\inc;..\User;..\User\imu;..\User\HARDWARE\key;..\User\HARDWARE\oled;..\User\Sys\delay;..\User\Sys\sys;..\User\Sys\usart;..\User\Sys\debug;..\User\Control;..\User\Communication;..\User\HARDWARE\ENCODER;..\User\HARDWARE\LED;..\User\HARDWARE\MOTOR;..\User\HARDWARE\PS2;..\User\HARDWARE\TIMER;..\User\HARDWARE\USART
  memory RVCT4: ROM 0x8000000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0xc000
  group STARTUP
    ../Libraries/startup/: startup_stm32f10x_hd.s
  group CMSIS
    ../Libraries/CMSIS/: system_stm32f10x.c
  group FWLIB
    ../Libraries/STM32F10x_StdPeriph_Driver/src/: misc.c stm32f10x_adc.c stm32f10x_bkp.c stm32f10x_can.c stm32f10x_cec.c stm32f10x_crc.c stm32f10x_dac.c stm32f10x_dbgmcu.c stm32f10x_dma.c stm32f10x_exti.c stm32f10x_flash.c stm32f10x_fsmc.c stm32f10x_gpio.c stm32f10x_i2c.c stm32f10x_iwdg.c stm32f10x_pwr.c stm32f10x_rcc.c stm32f10x_rtc.c stm32f10x_sdio.c stm32f10x_spi.c stm32f10x_tim.c stm32f10x_usart.c stm32f10x_wwdg.c
  group USER
    ../User/: stm32f10x_it.c main.cpp
  group DOC
    ../Doc/: Readme.txt
  group IMU-IIC
    ../User/imu/: iic.c imu.cpp sim-iic.c
  group HARDWARE
    ../User/HARDWARE/ENCODER/: encoder.cpp
    ../User/HARDWARE/KEY/: key.cpp
    ../User/HARDWARE/MOTOR/: motor.cpp
    ../User/HARDWARE/PS2/: pstwo.cpp
    ../User/HARDWARE/USART/: usart.cpp
  group System
    ../User/HARDWARE/TIMER/: timer.cpp
    ../User/Sys/delay/: delay.c
    ../User/Sys/sys/: sys.c
    ../User/Sys/debug/: debug.cpp
  group Control
    ../User/Control/: control.cpp
